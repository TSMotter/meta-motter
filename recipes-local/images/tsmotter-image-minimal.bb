require recipes-core/images/core-image-minimal.bb

IMAGE_INSTALL += "software-timer"